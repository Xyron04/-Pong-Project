# Keil uVision project Pong.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Pong
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c startup.s tm4c123gh6pm.h Nokia5110.c Nokia5110.h Terminal3.h Terminal6.h Terminal12.h Biblioteca_teclado.c Biblioteca_pulsadores.c Biblioteca_pulsadores.h
